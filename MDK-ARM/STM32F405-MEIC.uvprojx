# Keil uVision project STM32F405-MEIC.uvprojx, settings and files
target MEIC (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405-MEIC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c misc: --c99
  c include: ..\CORE;..\LIB\inc;..\MEIC_USER;..\MEIC_BSP\inc;..\MEIC_TASK\inc;..\MEIC_DRIVER\inc;..\MEIC_SYSTEM\UCOSIII_LIB;..\MEIC_SYSTEM\UCOSIII_CPU;..\MEIC_SYSTEM\UCOSIII_BSP;..\MEIC_SYSTEM\UCOSIII_CONFIG;..\MEIC_SYSTEM\UCOSIII_SRC\Source;..\MEIC_SYSTEM\UCOSIII_CPU\ARM-Cortex-M4\RealView;..\MEIC_SYSTEM\UCOSIII_LIB\Ports\ARM-Cortex-M4\RealView;..\MEIC_SYSTEM\UCOSIII_SRC\Ports\ARM-Cortex-M4\Generic\RealView
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../MEIC_USER/: main.c stm32f4xx_it.c Config.h
  group Driver
    ../MEIC_DRIVER/src/: Driver_IIC.c Driver_PID.c Driver_CAN.c Driver_Ramp.c Driver_DBUS.c Driver_USART.c Driver_Remoter.c Driver_FricMotor.c Driver_DotShoot.c Driver_MPU6050.c Driver_KMControl.c Driver_RMControl.c Driver_ComputerVision.c
  group Task
    ../MEIC_TASK/src/: Task_IMU.c Task_SysInit.c Task_CanTx.c Task_Control.c Task_Monitor.c Task_DebugMsg.c
  group BSP
    ../MEIC_BSP/src/: BSP_IIC.c BSP_TIM.c BSP_ALL.c BSP_CAN.c BSP_EXTI.c BSP_NVIC.c BSP_UART.c
  group Core
    ../CORE/startup/: startup_stm32f40_41xxx.s
    ../CORE/: system_stm32f4xx.c
  group Std_Lib
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UCOSIII_BSP
    ../MEIC_SYSTEM/UCOSIII_BSP/: bsp.c
  group UCOSIII_CONFIG
    ../MEIC_SYSTEM/UCOSIII_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII_CPU
    ../MEIC_SYSTEM/UCOSIII_CPU/: cpu_core.c
    ../MEIC_SYSTEM/UCOSIII_CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII_LIB
    ../MEIC_SYSTEM/UCOSIII_LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../MEIC_SYSTEM/UCOSIII_LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_SRC
    ../MEIC_SYSTEM/UCOSIII_SRC/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../MEIC_SYSTEM/UCOSIII_SRC/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
